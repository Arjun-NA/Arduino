int genMatrix[10][10]= {  0,0,0,0,0,0,0,0,0,0,
                          0,0,0,0,1,0,0,0,0,0,
                          0,0,0,1,0,0,1,0,0,0,
                          0,0,1,0,0,1,0,0,1,0,
                          0,1,0,1,0,1,0,1,0,0,
                          1,0,1,0,1,0,1,0,1,0,
                          1,1,0,1,1,0,1,1,0,1,
                          1,1,1,0,1,1,0,1,1,1,
                          1,1,1,1,0,1,1,1,1,1,
                          1,1,1,1,1,1,1,1,1,1   };

void gen(int M[8][16],int N[8][16],int O[8][16])
{
  uint16_t R[8]={0,0,0,0,0,0,0,0},G[8]={0,0,0,0,0,0,0,0},B[8]={0,0,0,0,0,0,0,0};
  
  for(int f=0;f<10;f++)
  { for(int i=0;i<8;i++)
    {  for(int j=0;j<16;j++)
        { R[i]<<=1;
          R[i]+=genMatrix[M[i][j]][f];
          G[i]<<=1;
          G[i]+=genMatrix[N[i][j]][f];
          B[i]<<=1;
          B[i]+=genMatrix[O[i][j]][f];
        }
        
    }show(R,G,B);
    for(int i=0;i<8;i++)
    {R[i]=0;
     G[i]=0;
     B[i]=0;
    }
  }
}
